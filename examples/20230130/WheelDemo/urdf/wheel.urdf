Commit message: change moi for wheel demo on jan 30 that was never used

File: examples/20230130/WheelDemo/urdf/wheel.urdf (robot description, URDF)
Before this commit: robot wheel, 4 links, 3 joints
Links:
- link wheel_link: mass 1.5707963267948966 -> 1
